Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView]
Time: 2026-09-23T23:06:12
Written by: IfcOpenShell 0.8.0
Made in: IfcOpenShell 0.8.0

# IfcBuildingElementProxy: anchor (4)
In: Product coordinate system
Description: * PROPOSED - NOT FOR FABRICATION; PredefinedType: USERDEFINED
Pset_TI_Product - ProductName: Modular GRP anti-glare screen; ProductCode: AG-600; ProductGroup: GRP anti-glare screens; DrawingLanguage: English; LengthUnit: mm; Brand: Traffic Industries; BrandWebsite: https://trafficindustries.com/; Supplier: MIR GROUP; CompanyEmail: info@trafficindustries.com; RailWidth_mm: 125; RailThickness_mm: 20; BladeWidth_mm: 125; BladeWallThickness_mm: 5; BladeHeight_mm: 600; BladeSpacing_mm: 250; AngleFromRail_deg: 65; AngleFromTransverse_deg: 25; RailColour: white; BladeColour: yellow; MetalFinish: galvanized; Anchor: M10 x 100; AnchorApproxSpacing_mm: 1000; ReflectorWidth_mm: 70; ReflectorHeight_mm: 150; ReflectorFaces: 2; ReflectorSpacing_mm: 2500; ReviewScope: PROPOSED DIMENSIONS * - NOT FOR FABRICATION; ParameterSHA256: 6e4413447980f1e2c7410f5e19c16fcb69309fe2a009a47dd50112c01e56b2ce
Name
anchor_00
anchor_01
anchor_02
anchor_03

# IfcBuildingElementProxy: base (16)
In: Product coordinate system
Description: * PROPOSED - NOT FOR FABRICATION; PredefinedType: USERDEFINED
Pset_TI_Product - ProductName: Modular GRP anti-glare screen; ProductCode: AG-600; ProductGroup: GRP anti-glare screens; DrawingLanguage: English; LengthUnit: mm; Brand: Traffic Industries; BrandWebsite: https://trafficindustries.com/; Supplier: MIR GROUP; CompanyEmail: info@trafficindustries.com; RailWidth_mm: 125; RailThickness_mm: 20; BladeWidth_mm: 125; BladeWallThickness_mm: 5; BladeHeight_mm: 600; BladeSpacing_mm: 250; AngleFromRail_deg: 65; AngleFromTransverse_deg: 25; RailColour: white; BladeColour: yellow; MetalFinish: galvanized; Anchor: M10 x 100; AnchorApproxSpacing_mm: 1000; ReflectorWidth_mm: 70; ReflectorHeight_mm: 150; ReflectorFaces: 2; ReflectorSpacing_mm: 2500; ReviewScope: PROPOSED DIMENSIONS * - NOT FOR FABRICATION; ParameterSHA256: 6e4413447980f1e2c7410f5e19c16fcb69309fe2a009a47dd50112c01e56b2ce
Name
base_00
base_01
base_02
base_03
base_04
base_05
base_06
base_07
base_08
base_09
base_10
base_11
base_12
base_13
base_14
base_15

# IfcBuildingElementProxy: base_screw (32)
In: Product coordinate system
Description: * PROPOSED - NOT FOR FABRICATION; PredefinedType: USERDEFINED
Pset_TI_Product - ProductName: Modular GRP anti-glare screen; ProductCode: AG-600; ProductGroup: GRP anti-glare screens; DrawingLanguage: English; LengthUnit: mm; Brand: Traffic Industries; BrandWebsite: https://trafficindustries.com/; Supplier: MIR GROUP; CompanyEmail: info@trafficindustries.com; RailWidth_mm: 125; RailThickness_mm: 20; BladeWidth_mm: 125; BladeWallThickness_mm: 5; BladeHeight_mm: 600; BladeSpacing_mm: 250; AngleFromRail_deg: 65; AngleFromTransverse_deg: 25; RailColour: white; BladeColour: yellow; MetalFinish: galvanized; Anchor: M10 x 100; AnchorApproxSpacing_mm: 1000; ReflectorWidth_mm: 70; ReflectorHeight_mm: 150; ReflectorFaces: 2; ReflectorSpacing_mm: 2500; ReviewScope: PROPOSED DIMENSIONS * - NOT FOR FABRICATION; ParameterSHA256: 6e4413447980f1e2c7410f5e19c16fcb69309fe2a009a47dd50112c01e56b2ce
Name
base_screw_00_0
base_screw_00_1
base_screw_01_0
base_screw_01_1
base_screw_02_0
base_screw_02_1
base_screw_03_0
base_screw_03_1
base_screw_04_0
base_screw_04_1
base_screw_05_0
base_screw_05_1
base_screw_06_0
base_screw_06_1
base_screw_07_0
base_screw_07_1
base_screw_08_0
base_screw_08_1
base_screw_09_0
base_screw_09_1
base_screw_10_0
base_screw_10_1
base_screw_11_0
base_screw_11_1
base_screw_12_0
base_screw_12_1
base_screw_13_0
base_screw_13_1
base_screw_14_0
base_screw_14_1
base_screw_15_0
base_screw_15_1

# IfcBuildingElementProxy: blade (16)
In: Product coordinate system
Description: Source dimension; PredefinedType: USERDEFINED
Pset_TI_Product - ProductName: Modular GRP anti-glare screen; ProductCode: AG-600; ProductGroup: GRP anti-glare screens; DrawingLanguage: English; LengthUnit: mm; Brand: Traffic Industries; BrandWebsite: https://trafficindustries.com/; Supplier: MIR GROUP; CompanyEmail: info@trafficindustries.com; RailWidth_mm: 125; RailThickness_mm: 20; BladeWidth_mm: 125; BladeWallThickness_mm: 5; BladeHeight_mm: 600; BladeSpacing_mm: 250; AngleFromRail_deg: 65; AngleFromTransverse_deg: 25; RailColour: white; BladeColour: yellow; MetalFinish: galvanized; Anchor: M10 x 100; AnchorApproxSpacing_mm: 1000; ReflectorWidth_mm: 70; ReflectorHeight_mm: 150; ReflectorFaces: 2; ReflectorSpacing_mm: 2500; ReviewScope: PROPOSED DIMENSIONS * - NOT FOR FABRICATION; ParameterSHA256: 6e4413447980f1e2c7410f5e19c16fcb69309fe2a009a47dd50112c01e56b2ce
Name
blade_00
blade_01
blade_02
blade_03
blade_04
blade_05
blade_06
blade_07
blade_08
blade_09
blade_10
blade_11
blade_12
blade_13
blade_14
blade_15

# IfcBuildingElementProxy: blade_bolt (32)
In: Product coordinate system
Description: * PROPOSED - NOT FOR FABRICATION; PredefinedType: USERDEFINED
Pset_TI_Product - ProductName: Modular GRP anti-glare screen; ProductCode: AG-600; ProductGroup: GRP anti-glare screens; DrawingLanguage: English; LengthUnit: mm; Brand: Traffic Industries; BrandWebsite: https://trafficindustries.com/; Supplier: MIR GROUP; CompanyEmail: info@trafficindustries.com; RailWidth_mm: 125; RailThickness_mm: 20; BladeWidth_mm: 125; BladeWallThickness_mm: 5; BladeHeight_mm: 600; BladeSpacing_mm: 250; AngleFromRail_deg: 65; AngleFromTransverse_deg: 25; RailColour: white; BladeColour: yellow; MetalFinish: galvanized; Anchor: M10 x 100; AnchorApproxSpacing_mm: 1000; ReflectorWidth_mm: 70; ReflectorHeight_mm: 150; ReflectorFaces: 2; ReflectorSpacing_mm: 2500; ReviewScope: PROPOSED DIMENSIONS * - NOT FOR FABRICATION; ParameterSHA256: 6e4413447980f1e2c7410f5e19c16fcb69309fe2a009a47dd50112c01e56b2ce
Name
blade_bolt_00_0
blade_bolt_00_1
blade_bolt_01_0
blade_bolt_01_1
blade_bolt_02_0
blade_bolt_02_1
blade_bolt_03_0
blade_bolt_03_1
blade_bolt_04_0
blade_bolt_04_1
blade_bolt_05_0
blade_bolt_05_1
blade_bolt_06_0
blade_bolt_06_1
blade_bolt_07_0
blade_bolt_07_1
blade_bolt_08_0
blade_bolt_08_1
blade_bolt_09_0
blade_bolt_09_1
blade_bolt_10_0
blade_bolt_10_1
blade_bolt_11_0
blade_bolt_11_1
blade_bolt_12_0
blade_bolt_12_1
blade_bolt_13_0
blade_bolt_13_1
blade_bolt_14_0
blade_bolt_14_1
blade_bolt_15_0
blade_bolt_15_1

# IfcBuildingElementProxy: rail
In: Product coordinate system
Description: * PROPOSED - NOT FOR FABRICATION; PredefinedType: USERDEFINED
Pset_TI_Product - ProductName: Modular GRP anti-glare screen; ProductCode: AG-600; ProductGroup: GRP anti-glare screens; DrawingLanguage: English; LengthUnit: mm; Brand: Traffic Industries; BrandWebsite: https://trafficindustries.com/; Supplier: MIR GROUP; CompanyEmail: info@trafficindustries.com; RailWidth_mm: 125; RailThickness_mm: 20; BladeWidth_mm: 125; BladeWallThickness_mm: 5; BladeHeight_mm: 600; BladeSpacing_mm: 250; AngleFromRail_deg: 65; AngleFromTransverse_deg: 25; RailColour: white; BladeColour: yellow; MetalFinish: galvanized; Anchor: M10 x 100; AnchorApproxSpacing_mm: 1000; ReflectorWidth_mm: 70; ReflectorHeight_mm: 150; ReflectorFaces: 2; ReflectorSpacing_mm: 2500; ReviewScope: PROPOSED DIMENSIONS * - NOT FOR FABRICATION; ParameterSHA256: 6e4413447980f1e2c7410f5e19c16fcb69309fe2a009a47dd50112c01e56b2ce

# IfcBuildingElementProxy: reflector (4)
In: Product coordinate system
Description: * PROPOSED - NOT FOR FABRICATION; PredefinedType: USERDEFINED
Pset_TI_Product - ProductName: Modular GRP anti-glare screen; ProductCode: AG-600; ProductGroup: GRP anti-glare screens; DrawingLanguage: English; LengthUnit: mm; Brand: Traffic Industries; BrandWebsite: https://trafficindustries.com/; Supplier: MIR GROUP; CompanyEmail: info@trafficindustries.com; RailWidth_mm: 125; RailThickness_mm: 20; BladeWidth_mm: 125; BladeWallThickness_mm: 5; BladeHeight_mm: 600; BladeSpacing_mm: 250; AngleFromRail_deg: 65; AngleFromTransverse_deg: 25; RailColour: white; BladeColour: yellow; MetalFinish: galvanized; Anchor: M10 x 100; AnchorApproxSpacing_mm: 1000; ReflectorWidth_mm: 70; ReflectorHeight_mm: 150; ReflectorFaces: 2; ReflectorSpacing_mm: 2500; ReviewScope: PROPOSED DIMENSIONS * - NOT FOR FABRICATION; ParameterSHA256: 6e4413447980f1e2c7410f5e19c16fcb69309fe2a009a47dd50112c01e56b2ce
Name
reflector_00_n
reflector_00_p
reflector_10_n
reflector_10_p

# IfcBuildingElementProxy: representative_barrier, barrier
In: Product coordinate system
Description: * PROPOSED - NOT FOR FABRICATION; PredefinedType: USERDEFINED
Pset_TI_Product - ProductName: Modular GRP anti-glare screen; ProductCode: AG-600; ProductGroup: GRP anti-glare screens; DrawingLanguage: English; LengthUnit: mm; Brand: Traffic Industries; BrandWebsite: https://trafficindustries.com/; Supplier: MIR GROUP; CompanyEmail: info@trafficindustries.com; RailWidth_mm: 125; RailThickness_mm: 20; BladeWidth_mm: 125; BladeWallThickness_mm: 5; BladeHeight_mm: 600; BladeSpacing_mm: 250; AngleFromRail_deg: 65; AngleFromTransverse_deg: 25; RailColour: white; BladeColour: yellow; MetalFinish: galvanized; Anchor: M10 x 100; AnchorApproxSpacing_mm: 1000; ReflectorWidth_mm: 70; ReflectorHeight_mm: 150; ReflectorFaces: 2; ReflectorSpacing_mm: 2500; ReviewScope: PROPOSED DIMENSIONS * - NOT FOR FABRICATION; ParameterSHA256: 6e4413447980f1e2c7410f5e19c16fcb69309fe2a009a47dd50112c01e56b2ce
